# Keil uVision project HC32F072.uvprojx, settings and files
target DemoProject (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: HC32F072KATA HDSC
  pack: HDSC.HC32F072.1.0.1
  cpu: IRAM(0x20000000,0x4000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: HC32F072 +hex
  AfterMake: cmd.bat
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\source\app;.\source\common;.\source\core;.\source\dev;.\source\driver\inc;.\source\driver\src;.\source\FreeRTOS\source;.\source\FreeRTOS\include;.\source\FreeRTOS\portable\MemMang;.\source\FreeRTOS\portable\RVDS\ARM_CM0
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group core
    ./source/core/: main.c startup_hc32f072.s
  group app
    ./source/app/: app_Led.c app_Task.c
  group dev
    ./source/dev/: dev_clk.c dev_gpio.c
  group driver
    ./source/driver/src/: adc.c adt.c aes.c bgr.c bt.c can.c crc.c dac.c ddl.c debug.c dmac.c flash.c gpio.c hdiv.c i2c.c i2s.c lpm.c lpuart.c lvd.c opa.c pca.c ram.c reset.c spi.c sysctrl.c timer3.c trim.c trng.c uart.c vc.c wdt.c
  group common
    ./source/common/: interrupts_hc32f072.c system_hc32f072.c
  group FreeRTOS/src
    ./source/FreeRTOS/source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group FreeRTOS/port
    ./source/FreeRTOS/portable/MemMang/: heap_4.c
    ./source/FreeRTOS/portable/RVDS/ARM_CM0/: port.c
  group FreeRTOS/config
    ./source/FreeRTOS/include/: FreeRTOSConfig.h
software components: CMSIS:CORE 5.4.0
